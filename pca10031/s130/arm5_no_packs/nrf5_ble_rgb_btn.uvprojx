# Keil uVision project nrf5_ble_rgb_btn.uvprojx, settings and files
target nrf51442_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_rgb_btn_s130 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10031 NRF_LOG_USES_RTT=1 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51
  c include: ..\..\..\config\ble_app_uart_s132_pca10040;..\..\..\config;..\..\..\..\nRF5_SDK_v11.0.0\components\ble\ble_advertising;..\..\..\..\nRF5_SDK_v11.0.0\components\ble\common;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\common;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\config;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\delay;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\gpiote;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\hal;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\pstorage;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\button;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\experimental_section_vars;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\fifo;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\fstorage;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\fstorage\config;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\timer;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\uart;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\util;..\..\..\..\nRF5_SDK_v11.0.0\components\softdevice\common\softdevice_handler;..\..\..\..\nRF5_SDK_v11.0.0\components\softdevice\s132\headers;..\..\..\..\nRF5_SDK_v11.0.0\components\softdevice\s132\headers\nrf52;..\..\..\..\nRF5_SDK_v11.0.0\components\toolchain;..\..\..\..\nRF5_SDK_v11.0.0\external\segger_rtt;..\..\..\..\nRF5_SDK_v11.0.0\components\libraries\pwm;..\..\..\..\nRF5_SDK_v11.0.0\examples\bsp;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\timer;..\..\..\..\nRF5_SDK_v11.0.0\components\drivers_nrf\ppi
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002080 size 0x5f80
  group Application
    ../../../: main.c ble_rgb_btn.c
  group nRF_BLE
    ../../../../nRF5_SDK_v11.0.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../nRF5_SDK_v11.0.0/components/ble/ble_advertising/: ble_advertising.c
  group nRF_Drivers
    ../../../../nRF5_SDK_v11.0.0/components/drivers_nrf/delay/: nrf_delay.c
    ../../../../nRF5_SDK_v11.0.0/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nRF5_SDK_v11.0.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nRF5_SDK_v11.0.0/components/drivers_nrf/pstorage/: pstorage.c
    ../../../../nRF5_SDK_v11.0.0/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../nRF5_SDK_v11.0.0/components/drivers_nrf/ppi/: nrf_drv_ppi.c
  group nRF_Libraries
    ../../../../nRF5_SDK_v11.0.0/components/libraries/button/: app_button.c
    ../../../../nRF5_SDK_v11.0.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../nRF5_SDK_v11.0.0/components/libraries/fifo/: app_fifo.c
    ../../../../nRF5_SDK_v11.0.0/components/libraries/timer/: app_timer.c
    ../../../../nRF5_SDK_v11.0.0/components/libraries/fstorage/: fstorage.c
    ../../../../nRF5_SDK_v11.0.0/components/libraries/uart/: retarget.c
    ../../../../nRF5_SDK_v11.0.0/components/libraries/pwm/: app_pwm.c
  group nRF_Segger_RTT
    ../../../../nRF5_SDK_v11.0.0/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../nRF5_SDK_v11.0.0/components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../../../../nRF5_SDK_v11.0.0/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_uart_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0, Device:Startup 8.5.0
